## boards/shields/SomberVMINI/Kconfig.defconfig
```kconfig
if ZMK_SHIELD_SOMBERVMINI

config ZMK_KEYBOARD_NAME
    default "SomberVMINI"

endif
```
